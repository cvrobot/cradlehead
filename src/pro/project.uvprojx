# Keil uVision project project.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c misc: --gnu
  c include: ..\src;..\lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../lib/: stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c stm32f10x.h stm32f10x_adc.h stm32f10x_conf.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_tim.h stm32f10x_usart.h system_stm32f10x.h startup_stm32f10x_md.s
  group src
    ../src/: cli.c config.c digital.c getbuildnum.c main.cpp misc.c run.cpp serial.c buildnum.h cli.h config.h core_cm3.h digital.h getbuildnum.h main.h misc.h rcc.h run.h serial.h simplebgc.cpp simplebgc.h simplewofl.cpp simplewofl.h rcc.c
  group SBGC_lib
    ../src/SBGC_lib/: SBGC_cmd_helpers.cpp SBGC.h
    ../src/SBGC_lib/include/: SBGC_rc.h SBGC_parser.h SBGC_command.h SBGC_cmd_helpers.h SBGC_adj_vars.h
  group WOFL_lib
    ../src/wofl_lib/: wofl_helper.cpp wofl.h
    ../src/wofl_lib/include/: wofl_cmd.h wofl_helper.h wofl_paser.h
software components: CMSIS:CORE 4.1.0
